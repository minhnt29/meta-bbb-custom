FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://spi2.patch"
